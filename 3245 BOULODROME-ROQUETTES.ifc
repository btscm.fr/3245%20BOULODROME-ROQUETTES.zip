Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcPlate: PL10*100 (20)
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = Weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2)
GOUSSET | 6226.19 | 5843.56 | 13686.3 | +6.193 | +6.258 | A2 | CV3 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 7196.92 | 8785.15 | 11196.1 | +7.163 | +7.227 | A2 | CV2 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 6321.03 | 6130.94 | 13478.6 | +6.290 | +6.355 | A2 | CV2 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 4749.4 | 1368.43 | 11177.5 | +4.717 | +4.783 | A2 | CV3 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 6226.19 | 5843.56 | 13513.7 | +6.193 | +6.258 | A2 | CV3 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 6264.96 | 5992.94 | 15994.8 | +6.216 | +6.314 | A1 | CV1 | 1.16672 | 0.000148627 | 29.5612 | 0.0344898
GOUSSET | 6264.96 | 5992.94 | 11205.2 | +6.216 | +6.314 | A1 | CV1 | 1.16672 | 0.000148627 | 29.5612 | 0.0344898

# IfcPlate: PL10*77 (48)
In: Undefined
Description: PL10*77; Material: STEEL/S235JR
Tekla Common - Phase: 2; Class: 3; Grade: S235JR; Profile: PL10*77; Name: RAIDISSEUR; sets with these values: 2
Tekla Quantity - Net weight: 0.786256 kg; Gross weight: 0.803919 kg; Weight: 0.786256 kg; Net volume: 0.00010016 m3; Gross volume: 0.00010016 m3; Gross footprint area: 0 m2; Area per tons: 30.596 m2; Net surface area: 0.0240563 m2; Gross area: 0.010241 m2; Height: 77 mm; Width: 10 mm; Length: 133 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark
RAIDISSEUR | 6261.82 | 11816.6 | 25957.7 | +6.197 | +6.327 | R2 | 6
RAIDISSEUR | 6261.82 | 11816.6 | 26042.3 | +6.197 | +6.327 | R2 | 6
RAIDISSEUR | 4708.43 | 16523.8 | 25957.7 | +4.644 | +4.773 | R2 | 6
RAIDISSEUR | 4708.43 | 16523.8 | 26042.3 | +4.644 | +4.773 | R2 | 6
RAIDISSEUR | 6261.82 | 5983.44 | 26042.3 | +6.197 | +6.327 | R2 | 3
RAIDISSEUR | 6261.82 | 5983.44 | 25957.7 | +6.197 | +6.327 | R2 | 3
RAIDISSEUR | 4708.43 | 1276.18 | 26042.3 | +4.644 | +4.773 | R2 | 3
RAIDISSEUR | 4708.43 | 1276.18 | 25957.7 | +4.644 | +4.773 | R2 | 3
RAIDISSEUR | 6261.82 | 11816.6 | 21057.7 | +6.197 | +6.327 | R2 | 6
RAIDISSEUR | 6261.82 | 11816.6 | 21142.3 | +6.197 | +6.327 | R2 | 6
RAIDISSEUR | 4708.43 | 16523.8 | 21057.7 | +4.644 | +4.773 | R2 | 6
RAIDISSEUR | 4708.43 | 16523.8 | 21142.3 | +4.644 | +4.773 | R2 | 6
RAIDISSEUR | 6261.82 | 5983.44 | 21142.3 | +6.197 | +6.327 | R2 | 3
RAIDISSEUR | 6261.82 | 5983.44 | 21057.7 | +6.197 | +6.327 | R2 | 3
RAIDISSEUR | 4708.43 | 1276.18 | 21142.3 | +4.644 | +4.773 | R2 | 3
RAIDISSEUR | 4708.43 | 1276.18 | 21057.7 | +4.644 | +4.773 | R2 | 3
RAIDISSEUR | 6261.82 | 11816.6 | 16057.7 | +6.197 | +6.327 | R1 | 5
RAIDISSEUR | 6261.82 | 11816.6 | 16142.3 | +6.197 | +6.327 | R2 | 5
RAIDISSEUR | 4708.43 | 16523.8 | 16057.7 | +4.644 | +4.773 | R2 | 5
RAIDISSEUR | 4708.43 | 16523.8 | 16142.3 | +4.644 | +4.773 | R2 | 5
RAIDISSEUR | 6261.82 | 5983.44 | 16142.3 | +6.197 | +6.327 | R2 | 2
RAIDISSEUR | 6261.82 | 5983.44 | 16057.7 | +6.197 | +6.327 | R1 | 2
RAIDISSEUR | 4708.43 | 1276.18 | 16142.3 | +4.644 | +4.773 | R2 | 2
RAIDISSEUR | 4708.43 | 1276.18 | 16057.7 | +4.644 | +4.773 | R2 | 2
RAIDISSEUR | 6261.82 | 11816.6 | 11057.7 | +6.197 | +6.327 | R2 | 4
RAIDISSEUR | 6261.82 | 11816.6 | 11142.3 | +6.197 | +6.327 | R1 | 4
RAIDISSEUR | 4708.43 | 16523.8 | 11057.7 | +4.644 | +4.773 | R2 | 4
RAIDISSEUR | 4708.43 | 16523.8 | 11142.3 | +4.644 | +4.773 | R2 | 4
RAIDISSEUR | 6261.82 | 5983.44 | 11142.3 | +6.197 | +6.327 | R1 | 1
RAIDISSEUR | 6261.82 | 5983.44 | 11057.7 | +6.197 | +6.327 | R2 | 1
RAIDISSEUR | 4708.43 | 1276.18 | 11142.3 | +4.644 | +4.773 | R2 | 1
RAIDISSEUR | 4708.43 | 1276.18 | 11057.7 | +4.644 | +4.773 | R2 | 1
RAIDISSEUR | 6261.82 | 11816.6 | 6057.75 | +6.197 | +6.327 | R2 | 6
RAIDISSEUR | 6261.82 | 11816.6 | 6142.25 | +6.197 | +6.327 | R2 | 6
RAIDISSEUR | 4708.43 | 16523.8 | 6057.75 | +4.644 | +4.773 | R2 | 6
RAIDISSEUR | 4708.43 | 16523.8 | 6142.25 | +4.644 | +4.773 | R2 | 6
RAIDISSEUR | 6261.82 | 5983.44 | 6142.25 | +6.197 | +6.327 | R2 | 3
RAIDISSEUR | 6261.82 | 5983.44 | 6057.75 | +6.197 | +6.327 | R2 | 3
RAIDISSEUR | 4708.43 | 1276.18 | 6142.25 | +4.644 | +4.773 | R2 | 3
RAIDISSEUR | 4708.43 | 1276.18 | 6057.75 | +4.644 | +4.773 | R2 | 3
RAIDISSEUR | 6261.82 | 11816.6 | 1157.75 | +6.197 | +6.327 | R2 | 6
RAIDISSEUR | 6261.82 | 11816.6 | 1242.25 | +6.197 | +6.327 | R2 | 6
RAIDISSEUR | 4708.43 | 16523.8 | 1157.75 | +4.644 | +4.773 | R2 | 6
RAIDISSEUR | 4708.43 | 16523.8 | 1242.25 | +4.644 | +4.773 | R2 | 6
RAIDISSEUR | 4708.43 | 1276.18 | 1157.75 | +4.644 | +4.773 | R2 | 3
RAIDISSEUR | 4708.43 | 1276.18 | 1242.25 | +4.644 | +4.773 | R2 | 3
RAIDISSEUR | 6261.82 | 5983.44 | 1157.75 | +6.197 | +6.327 | R2 | 3
RAIDISSEUR | 6261.82 | 5983.44 | 1242.25 | +6.197 | +6.327 | R2 | 3
