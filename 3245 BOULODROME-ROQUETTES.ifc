Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
File name: 3245 BOULODROME-ROQUETTES.ifc
Time: 2011-07-12T17:19:12
Author: ABRIAND/BOINEAUP
Organization: Structural Designer
Written by: IFC Database Version:Work
Made in: Tekla Structures 18.1 Build:12518/10.9.2012, IFC Export Version: 309Mar 29 2012

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: 4525*270 (4)
In: Undefined
Description: 4525*270; Material: CONCRETE/K40-1
Tekla Common - Center of gravity Z: 1962.5 mm; Center of gravity Y: 16500 mm; Bottom elevation: -0.300; Top elevation: +4.225; Part mark: AB1; Assembly mark: AB1; Phase: 1; Class: 1; Finish: BETON; Grade: K40-1; Profile: 4525*270; Name: POUTRE; sets with these values: 2
Tekla Quantity - Net weight: 7623.72 kg; Gross weight: 7623.72 kg; Weight: 7623.72 kg; Net volume: 3.17655 m3; Gross volume: 3.17655 m3; Gross footprint area: 0.702 m2; Area per tons: 3.59109 m2; Net surface area: 27.3775 m2; Gross area: 27.3775 m2; Height: 4525 mm; Width: 270 mm; Length: 2600 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 2600 mm; OuterSurfaceArea: 27.3775 m2; NetVolume: 3.17655 m3; NetWeight: 7623.72 kg
Name | Center of gravity X (mm)
POUTRE | 300
POUTRE | 10700
POUTRE | 16500
POUTRE | 26900

# IfcBeam: 600*600 (8)
In: Undefined
Description: 600*600; Material: CONCRETE/K40-1
Tekla Common - Center of gravity Z: 1962.5 mm; Bottom elevation: -0.300; Top elevation: +4.225; Part mark: PB1; Assembly mark: PB1; Phase: 1; Class: 1; Finish: BETON; Grade: K40-1; Profile: 600*600; Name: POTEAU; sets with these values: 2
Tekla Quantity - Net weight: 3909.6 kg; Gross weight: 3909.6 kg; Weight: 3909.6 kg; Net volume: 1.629 m3; Gross volume: 1.629 m3; Gross footprint area: 0.36 m2; Area per tons: 2.96194 m2; Net surface area: 11.58 m2; Gross area: 11.58 m2; Height: 600 mm; Width: 600 mm; Length: 4525 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 4525 mm; OuterSurfaceArea: 11.58 m2; NetVolume: 1.629 m3; NetWeight: 3909.6 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm)
POTEAU | 1300 | 1200
POTEAU | 1300 | 6100
POTEAU | 1300 | 11100
POTEAU | 1300 | 16100
POTEAU | 1300 | 21100
POTEAU | 1300 | 26000
POTEAU | 16500 | 6100
POTEAU | 16500 | 21100

# IfcBeam: HEA160 (12)
In: Undefined
Description: HEA160; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5799.53 mm; Bottom elevation: +4.306; Top elevation: +7.300; Part mark: T1; Phase: 2; Class: 3; Grade: S235JR; Profile: HEA160; Name: POUTRE; sets with these values: 2
Tekla Quantity - Net weight: 262.259 kg; Gross weight: 276.762 kg; Weight: 276.762 kg; Net volume: 0.0334088 m3; Gross volume: 0.0352563 m3; Gross footprint area: 0 m2; Area per tons: 29.7689 m2; Net surface area: 8.45951 m2; Gross area: 8.23889 m2; Height: 152 mm; Width: 160 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - OuterSurfaceArea: 8.23889 m2; NetVolume: 0.0334088 m3; NetWeight: 262.259 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POUTRE | 13217.9 | 26000 | 6 | 9093.69
POUTRE | 4582.07 | 26000 | 3 | 9093.69
POUTRE | 13217.9 | 21100 | 6 | 9093.69
POUTRE | 4582.07 | 21100 | 3 | 9093.69
POUTRE | 13217.9 | 16100 | 5 | 9093.69
POUTRE | 4582.07 | 16100 | 2 | 9093.69
POUTRE | 13217.9 | 11100 | 4 | 9093.69
POUTRE | 4582.07 | 11100 | 1 | 9093.69
POUTRE | 4582.07 | 1200 | 3 | 9093.7
POUTRE | 4582.07 | 6100 | 3 | 9093.69
POUTRE | 13217.9 | 1200 | 6 | 9093.69
POUTRE | 13217.9 | 6100 | 6 | 9093.69

# IfcBeam: PL10*100 (24)
In: Undefined
Description: PL10*100; Material: STEEL/S235JR
Tekla Common - Part mark: G1; Phase: 2; Class: 3; Grade: S235JR; Profile: PL10*100; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 1.76625 kg; Gross weight: 2.355 kg; Weight: 1.76625 kg; Net volume: 0.000225 m3; Gross volume: 0.000225 m3; Gross footprint area: 0.0015 m2; Area per tons: 29.4409 m2; Net surface area: 0.052 m2; Gross area: 0.03 m2; Height: 100 mm; Width: 10 mm; Length: 300 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 300 mm; OuterSurfaceArea: 0.052 m2; NetVolume: 0.000225 m3; NetWeight: 1.76625 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
GOUSSET | 4291.44 | 16574.9 | 26000 | +4.247 | +4.347 | 6
GOUSSET | 4291.44 | 16425.2 | 26000 | +4.247 | +4.347 | 6
GOUSSET | 4281.44 | 1225.15 | 26000 | +4.237 | +4.337 | 3
GOUSSET | 4281.44 | 1374.85 | 26000 | +4.237 | +4.337 | 3
GOUSSET | 4291.44 | 16574.9 | 21100 | +4.247 | +4.347 | 6
GOUSSET | 4291.44 | 16425.2 | 21100 | +4.247 | +4.347 | 6
GOUSSET | 4281.44 | 1225.15 | 21100 | +4.237 | +4.337 | 3
GOUSSET | 4281.44 | 1374.85 | 21100 | +4.237 | +4.337 | 3
GOUSSET | 4291.44 | 16574.9 | 16100 | +4.247 | +4.347 | 5
GOUSSET | 4291.44 | 16425.2 | 16100 | +4.247 | +4.347 | 5
GOUSSET | 4281.44 | 1225.15 | 16100 | +4.237 | +4.337 | 2
GOUSSET | 4281.44 | 1374.85 | 16100 | +4.237 | +4.337 | 2
GOUSSET | 4291.44 | 16574.9 | 11100 | +4.247 | +4.347 | 4
GOUSSET | 4291.44 | 16425.2 | 11100 | +4.247 | +4.347 | 4
GOUSSET | 4281.44 | 1225.15 | 11100 | +4.237 | +4.337 | 1
GOUSSET | 4281.44 | 1374.85 | 11100 | +4.237 | +4.337 | 1
GOUSSET | 4291.44 | 16574.9 | 6100 | +4.247 | +4.347 | 6
GOUSSET | 4291.44 | 16425.2 | 6100 | +4.247 | +4.347 | 6
GOUSSET | 4281.44 | 1225.15 | 6100 | +4.237 | +4.337 | 3
GOUSSET | 4281.44 | 1374.85 | 6100 | +4.237 | +4.337 | 3
GOUSSET | 4291.44 | 16574.9 | 1200 | +4.247 | +4.347 | 6
GOUSSET | 4291.44 | 16425.2 | 1200 | +4.247 | +4.347 | 6
GOUSSET | 4281.44 | 1374.85 | 1200 | +4.237 | +4.337 | 3
GOUSSET | 4281.44 | 1225.15 | 1200 | +4.237 | +4.337 | 3

# IfcBeam: PL10*246 (2)
In: Undefined
Description: PL10*246; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 6267.19 mm; Center of gravity X: 13600 mm; Bottom elevation: +6.216; Top elevation: +6.315; Part mark: G4; Assembly mark: CV1; Phase: 4; Class: 3; Grade: S235JR; Profile: PL10*246; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 4.90023 kg; Gross weight: 5.82045 kg; Weight: 4.90023 kg; Net volume: 0.000624233 m3; Gross volume: 0.000624233 m3; Gross footprint area: 0 m2; Area per tons: 27.4324 m2; Net surface area: 0.134425 m2; Gross area: 0.0741458 m2; Height: 245.573 mm; Width: 10 mm; Length: 301.93 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 301.93 mm; OuterSurfaceArea: 0.134425 m2; NetVolume: 0.000624233 m3; NetWeight: 4.90023 kg
Name | Center of gravity Y (mm)
GOUSSET | 11800.3
GOUSSET | 5999.7

# IfcBeam: PL10*280 (6)
In: Undefined
Description: PL10*280; Material: /Neoprene
Tekla Common - Center of gravity Z: 4230 mm; Center of gravity Y: 16500 mm; Bottom elevation: +4.225; Top elevation: +4.235; Part mark: 10; Assembly mark: 10; Phase: 2; Class: 4; Grade: Neoprene; Profile: PL10*280; Name: TEFLON; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000504 m3; Gross volume: 0.000504 m3; Gross footprint area: 0.0504 m2; Net surface area: 0.11 m2; Gross area: 0.11 m2; Height: 280 mm; Width: 10 mm; Length: 180 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 180 mm; OuterSurfaceArea: 0.11 m2; NetVolume: 0.000504 m3; NetWeight: 0 kg
Name | Center of gravity X (mm)
TEFLON | 26000
TEFLON | 21100
TEFLON | 16100
TEFLON | 11100
TEFLON | 1200
TEFLON | 6100

# IfcBeam: PL10*79 (4)
In: Undefined
Description: PL10*79; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 4722.3 mm; Bottom elevation: +4.705; Top elevation: +4.739; Part mark: G3; Phase: 2; Class: 3; Grade: S235JR; Profile: PL10*79; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0.483827 kg; Gross weight: 0.514041 kg; Weight: 0.483827 kg; Net volume: 0.000061634 m3; Gross volume: 0.000061634 m3; Gross footprint area: 0 m2; Area per tons: 31.667 m2; Net surface area: 0.0153213 m2; Gross area: 0.00654829 m2; Height: 78.9595 mm; Width: 10 mm; Length: 82.9323 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 82.9323 mm; OuterSurfaceArea: 0.0153213 m2; NetVolume: 0.000061634 m3; NetWeight: 0.483827 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
GOUSSET | 16481.8 | 11142.8 | 4
GOUSSET | 16481.8 | 16057.2 | 5
GOUSSET | 1318.22 | 11142.8 | 1
GOUSSET | 1318.22 | 16057.2 | 2

# IfcBeam: PL10*98 (4)
In: Undefined
Description: PL10*98; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 7204.31 mm; Bottom elevation: +7.184; Top elevation: +7.225; Part mark: G2; Phase: 2; Class: 3; Grade: S235JR; Profile: PL10*98; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0.661236 kg; Gross weight: 0.719491 kg; Weight: 0.661236 kg; Net volume: 0.0000842339 m3; Gross volume: 0.0000842339 m3; Gross footprint area: 0 m2; Area per tons: 30.8295 m2; Net surface area: 0.0203855 m2; Gross area: 0.00916549 m2; Height: 98.1671 mm; Width: 10 mm; Length: 93.3662 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 93.3662 mm; OuterSurfaceArea: 0.0203855 m2; NetVolume: 0.0000842339 m3; NetWeight: 0.661236 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
GOUSSET | 8960.53 | 11146.1 | 4
GOUSSET | 8960.53 | 16053.9 | 5
GOUSSET | 8839.46 | 16053.9 | 2
GOUSSET | 8839.46 | 11146.1 | 1

# IfcBeam: PL12*160 (12)
In: Undefined
Description: PL12*160; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 7220.33 mm; Bottom elevation: +7.135; Top elevation: +7.305; Part mark: A5; Phase: 2; Class: 3; Grade: S235JR; Profile: PL12*160; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 2.56318 kg; Gross weight: 2.56318 kg; Weight: 2.56318 kg; Net volume: 0.00032652 m3; Gross volume: 0.00032652 m3; Gross footprint area: 0.00192 m2; Area per tons: 24.3219 m2; Net surface area: 0.0623415 m2; Gross area: 0.0623415 m2; Height: 160 mm; Width: 12 mm; Length: 170.063 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 170.063 mm; OuterSurfaceArea: 0.0623415 m2; NetVolume: 0.00032652 m3; NetWeight: 2.56318 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
PLAT | 8906 | 26000 | 6
PLAT | 8894 | 26000 | 3
PLAT | 8906 | 21100 | 6
PLAT | 8894 | 21100 | 3
PLAT | 8906 | 16100 | 5
PLAT | 8894 | 16100 | 2
PLAT | 8906 | 11100 | 4
PLAT | 8894 | 11100 | 1
PLAT | 8906 | 6100 | 6
PLAT | 8894 | 6100 | 3
PLAT | 8906 | 1200 | 6
PLAT | 8894 | 1200 | 3

# IfcBeam: PL12*300 (12)
In: Undefined
Description: PL12*300; Material: STEEL/S235JR
Tekla Common - Phase: 2; Class: 3; Grade: S235JR; Profile: PL12*300; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 5.652 kg; Gross weight: 5.652 kg; Weight: 5.652 kg; Net volume: 0.00072 m3; Gross volume: 0.00072 m3; Gross footprint area: 0.06 m2; Area per tons: 23.3546 m2; Net surface area: 0.132 m2; Gross area: 0.132 m2; Height: 300 mm; Width: 12 mm; Length: 200 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.132 m2; NetVolume: 0.00072 m3; NetWeight: 5.652 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark
PLAT | 4241 | 16500 | 26000 | +4.235 | +4.247 | A4 | 6
PLAT | 4231 | 1300 | 26000 | +4.225 | +4.237 | A3 | 3
PLAT | 4241 | 16500 | 21100 | +4.235 | +4.247 | A4 | 6
PLAT | 4231 | 1300 | 21100 | +4.225 | +4.237 | A3 | 3
PLAT | 4241 | 16500 | 16100 | +4.235 | +4.247 | A4 | 5
PLAT | 4231 | 1300 | 16100 | +4.225 | +4.237 | A3 | 2
PLAT | 4241 | 16500 | 11100 | +4.235 | +4.247 | A4 | 4
PLAT | 4231 | 1300 | 11100 | +4.225 | +4.237 | A3 | 1
PLAT | 4241 | 16500 | 6100 | +4.235 | +4.247 | A4 | 6
PLAT | 4231 | 1300 | 6100 | +4.225 | +4.237 | A3 | 3
PLAT | 4231 | 1300 | 1200 | +4.225 | +4.237 | A3 | 3
PLAT | 4241 | 16500 | 1200 | +4.235 | +4.247 | A4 | 6

# IfcBeam: PL15*155 (12)
In: Undefined
Description: PL15*155; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 4556.64 mm; Bottom elevation: +4.372; Top elevation: +4.762; Part mark: OX1; Phase: 2; Class: 7; Grade: S235JR; Profile: PL15*155; Name: OXYCOUPAGE; sets with these values: 2
Tekla Quantity - Net weight: 13.5341 kg; Gross weight: 14.6013 kg; Weight: 13.5341 kg; Net volume: 0.00172409 m3; Gross volume: 0.00184827 m3; Gross footprint area: 0 m2; Area per tons: 19.5235 m2; Net surface area: 0.264232 m2; Gross area: 0.124002 m2; Height: 155.003 mm; Width: 15 mm; Length: 800.002 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 800.002 mm; OuterSurfaceArea: 0.264232 m2; NetVolume: 0.00172409 m3; NetWeight: 13.5341 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
OXYCOUPAGE | 1303.61 | 16100 | 2
OXYCOUPAGE | 16496.4 | 11100 | 4
OXYCOUPAGE | 16496.4 | 6100 | 6
OXYCOUPAGE | 1303.61 | 6100 | 3
OXYCOUPAGE | 16496.4 | 16100 | 5
OXYCOUPAGE | 1303.61 | 11100 | 1
OXYCOUPAGE | 1303.61 | 21100 | 3
OXYCOUPAGE | 16496.4 | 21100 | 6
OXYCOUPAGE | 1303.61 | 26000 | 3
OXYCOUPAGE | 16496.4 | 26000 | 6
OXYCOUPAGE | 16496.4 | 1200 | 6
OXYCOUPAGE | 1303.61 | 1200 | 3

# IfcBeam: PL15*178 (12)
In: Undefined
Description: PL15*178; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5312.51 mm; Bottom elevation: +5.211; Top elevation: +5.411; Part mark: OX2; Phase: 2; Class: 7; Grade: S235JR; Profile: PL15*178; Name: OXYCOUPAGE; sets with these values: 2
Tekla Quantity - Net weight: 4.85474 kg; Gross weight: 7.0157 kg; Weight: 4.85474 kg; Net volume: 0.000618438 m3; Gross volume: 0.000618438 m3; Gross footprint area: 0 m2; Area per tons: 21.8884 m2; Net surface area: 0.106263 m2; Gross area: 0.0595813 m2; Height: 178.395 mm; Width: 15 mm; Length: 333.985 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 333.985 mm; OuterSurfaceArea: 0.106263 m2; NetVolume: 0.000618438 m3; NetWeight: 4.85474 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
OXYCOUPAGE | 10485 | 26000 | 6
OXYCOUPAGE | 7315.02 | 11100 | 1
OXYCOUPAGE | 7315.02 | 16100 | 2
OXYCOUPAGE | 10485 | 6100 | 6
OXYCOUPAGE | 10485 | 11100 | 4
OXYCOUPAGE | 7315.02 | 6100 | 3
OXYCOUPAGE | 7315.02 | 21100 | 3
OXYCOUPAGE | 10485 | 16100 | 5
OXYCOUPAGE | 7315.02 | 26000 | 3
OXYCOUPAGE | 10485 | 21100 | 6
OXYCOUPAGE | 10485 | 1200 | 6
OXYCOUPAGE | 7315.02 | 1200 | 3

# IfcBeam: PL6*150 (28)
In: Undefined
Description: PL6*150; Material: STEEL/S235JR
Tekla Common - Part mark: A6; Assembly mark: 7; Phase: 3; Class: 5; Grade: S235JR; Profile: PL6*150; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 1.5543 kg; Gross weight: 1.5543 kg; Weight: 1.5543 kg; Net volume: 0.000198 m3; Gross volume: 0.000198 m3; Gross footprint area: 0 m2; Area per tons: 45.3194 m2; Net surface area: 0.07044 m2; Gross area: 0.07044 m2; Height: 150 mm; Width: 6 mm; Length: 220 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 220 mm; OuterSurfaceArea: 0.07044 m2; NetVolume: 0.000198 m3; NetWeight: 1.5543 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
PLAT | 7261.3 | 9039.91 | 26000 | +7.224 | +7.299
PLAT | 6799.07 | 10440.6 | 26000 | +6.762 | +6.836
PLAT | 6336.84 | 11841.3 | 26000 | +6.300 | +6.374
PLAT | 5874.61 | 13242 | 26000 | +5.837 | +5.912
PLAT | 5412.38 | 14642.7 | 26000 | +5.375 | +5.450
PLAT | 4950.15 | 16043.4 | 26000 | +4.913 | +4.987
PLAT | 7261.3 | 8760.09 | 26000 | +7.224 | +7.299
PLAT | 6799.07 | 7359.39 | 26000 | +6.762 | +6.836
PLAT | 6336.84 | 5958.69 | 26000 | +6.300 | +6.374
PLAT | 5874.61 | 4557.99 | 26000 | +5.837 | +5.912
PLAT | 5412.38 | 3157.29 | 26000 | +5.375 | +5.450
PLAT | 4950.15 | 1756.59 | 26000 | +4.913 | +4.987
PLAT | 4487.92 | 17444.1 | 26000 | +4.451 | +4.525
PLAT | 7261.3 | 9039.91 | 1200 | +7.224 | +7.299
PLAT | 6799.07 | 10440.6 | 1200 | +6.762 | +6.836
PLAT | 6336.84 | 11841.3 | 1200 | +6.300 | +6.374
PLAT | 5874.61 | 13242 | 1200 | +5.837 | +5.912
PLAT | 5412.38 | 14642.7 | 1200 | +5.375 | +5.450
PLAT | 4950.15 | 16043.4 | 1200 | +4.913 | +4.987
PLAT | 4487.92 | 17444.1 | 1200 | +4.451 | +4.525
PLAT | 4487.92 | 355.886 | 26000 | +4.451 | +4.525
PLAT | 4487.92 | 355.886 | 1200 | +4.451 | +4.525
PLAT | 4950.15 | 1756.59 | 1200 | +4.913 | +4.987
PLAT | 5412.38 | 3157.29 | 1200 | +5.375 | +5.450
PLAT | 5874.61 | 4557.99 | 1200 | +5.837 | +5.912
PLAT | 6336.84 | 5958.69 | 1200 | +6.300 | +6.374
PLAT | 6799.07 | 7359.39 | 1200 | +6.762 | +6.836
PLAT | 7261.3 | 8760.09 | 1200 | +7.224 | +7.299

# IfcBeam: PL6*70 (112)
In: Undefined
Description: PL6*70; Material: STEEL/S235JR
Tekla Common - Part mark: A7; Phase: 3; Class: 5; Grade: S235JR; Profile: PL6*70; Name: PLAT; sets with these values: 2
Tekla Quantity - Net weight: 0.72534 kg; Gross weight: 0.72534 kg; Weight: 0.72534 kg; Net volume: 0.0000924 m3; Gross volume: 0.0000924 m3; Gross footprint area: 0 m2; Area per tons: 47.2606 m2; Net surface area: 0.03428 m2; Gross area: 0.03428 m2; Height: 70 mm; Width: 6 mm; Length: 220 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 220 mm; OuterSurfaceArea: 0.03428 m2; NetVolume: 0.0000924 m3; NetWeight: 0.72534 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
PLAT | 7261.3 | 9039.91 | 6060 | +7.224 | +7.299 | 7
PLAT | 7261.3 | 9039.91 | 6140 | +7.224 | +7.299 | 8
PLAT | 7261.3 | 9039.91 | 11060 | +7.224 | +7.299 | 8
PLAT | 7261.3 | 9039.91 | 11140 | +7.224 | +7.299 | 8
PLAT | 7261.3 | 9039.91 | 21060 | +7.224 | +7.299 | 8
PLAT | 7261.3 | 9039.91 | 21140 | +7.224 | +7.299 | 7
PLAT | 7261.3 | 9039.91 | 16060 | +7.224 | +7.299 | 8
PLAT | 7261.3 | 9039.91 | 16140 | +7.224 | +7.299 | 8
PLAT | 6799.07 | 10440.6 | 6060 | +6.762 | +6.836 | 7
PLAT | 6799.07 | 10440.6 | 6140 | +6.762 | +6.836 | 8
PLAT | 6799.07 | 10440.6 | 11060 | +6.762 | +6.836 | 8
PLAT | 6799.07 | 10440.6 | 11140 | +6.762 | +6.836 | 8
PLAT | 6799.07 | 10440.6 | 21060 | +6.762 | +6.836 | 8
PLAT | 6799.07 | 10440.6 | 21140 | +6.762 | +6.836 | 7
PLAT | 6799.07 | 10440.6 | 16060 | +6.762 | +6.836 | 8
PLAT | 6799.07 | 10440.6 | 16140 | +6.762 | +6.836 | 8
PLAT | 6336.84 | 11841.3 | 6060 | +6.300 | +6.374 | 7
PLAT | 6336.84 | 11841.3 | 6140 | +6.300 | +6.374 | 8
PLAT | 6336.84 | 11841.3 | 11060 | +6.300 | +6.374 | 8
PLAT | 6336.84 | 11841.3 | 11140 | +6.300 | +6.374 | 8
PLAT | 6336.84 | 11841.3 | 21060 | +6.300 | +6.374 | 8
PLAT | 6336.84 | 11841.3 | 21140 | +6.300 | +6.374 | 7
PLAT | 6336.84 | 11841.3 | 16060 | +6.300 | +6.374 | 8
PLAT | 6336.84 | 11841.3 | 16140 | +6.300 | +6.374 | 8
PLAT | 5874.61 | 13242 | 6060 | +5.837 | +5.912 | 7
PLAT | 5874.61 | 13242 | 6140 | +5.837 | +5.912 | 8
PLAT | 5874.61 | 13242 | 11060 | +5.837 | +5.912 | 8
PLAT | 5874.61 | 13242 | 11140 | +5.837 | +5.912 | 8
PLAT | 5874.61 | 13242 | 21060 | +5.837 | +5.912 | 8
PLAT | 5874.61 | 13242 | 21140 | +5.837 | +5.912 | 7
PLAT | 5874.61 | 13242 | 16060 | +5.837 | +5.912 | 8
PLAT | 5874.61 | 13242 | 16140 | +5.837 | +5.912 | 8
PLAT | 5412.38 | 14642.7 | 6060 | +5.375 | +5.450 | 7
PLAT | 5412.38 | 14642.7 | 6140 | +5.375 | +5.450 | 8
PLAT | 5412.38 | 14642.7 | 11060 | +5.375 | +5.450 | 8
PLAT | 5412.38 | 14642.7 | 11140 | +5.375 | +5.450 | 8
PLAT | 5412.38 | 14642.7 | 21060 | +5.375 | +5.450 | 8
PLAT | 5412.38 | 14642.7 | 21140 | +5.375 | +5.450 | 7
PLAT | 5412.38 | 14642.7 | 16060 | +5.375 | +5.450 | 8
PLAT | 5412.38 | 14642.7 | 16140 | +5.375 | +5.450 | 8
PLAT | 4950.15 | 16043.4 | 6060 | +4.913 | +4.987 | 7
PLAT | 4950.15 | 16043.4 | 6140 | +4.913 | +4.987 | 8
PLAT | 4950.15 | 16043.4 | 11060 | +4.913 | +4.987 | 8
PLAT | 4950.15 | 16043.4 | 11140 | +4.913 | +4.987 | 8
PLAT | 4950.15 | 16043.4 | 21060 | +4.913 | +4.987 | 8
PLAT | 4950.15 | 16043.4 | 21140 | +4.913 | +4.987 | 7
PLAT | 4950.15 | 16043.4 | 16060 | +4.913 | +4.987 | 8
PLAT | 4950.15 | 16043.4 | 16140 | +4.913 | +4.987 | 8
PLAT | 4487.92 | 17444.1 | 21060 | +4.451 | +4.525 | 8
PLAT | 4487.92 | 17444.1 | 21140 | +4.451 | +4.525 | 7
PLAT | 4487.92 | 17444.1 | 16060 | +4.451 | +4.525 | 8
PLAT | 4487.92 | 17444.1 | 16140 | +4.451 | +4.525 | 8
PLAT | 4487.92 | 17444.1 | 11060 | +4.451 | +4.525 | 8
PLAT | 4487.92 | 17444.1 | 11140 | +4.451 | +4.525 | 8
PLAT | 7261.3 | 8760.09 | 11140 | +7.224 | +7.299 | 8
PLAT | 7261.3 | 8760.09 | 11060 | +7.224 | +7.299 | 8
PLAT | 7261.3 | 8760.09 | 16140 | +7.224 | +7.299 | 8
PLAT | 7261.3 | 8760.09 | 16060 | +7.224 | +7.299 | 8
PLAT | 7261.3 | 8760.09 | 21140 | +7.224 | +7.299 | 7
PLAT | 7261.3 | 8760.09 | 21060 | +7.224 | +7.299 | 8
PLAT | 6799.07 | 7359.39 | 11140 | +6.762 | +6.836 | 8
PLAT | 6799.07 | 7359.39 | 11060 | +6.762 | +6.836 | 8
PLAT | 6799.07 | 7359.39 | 16140 | +6.762 | +6.836 | 8
PLAT | 6799.07 | 7359.39 | 16060 | +6.762 | +6.836 | 8
PLAT | 6799.07 | 7359.39 | 21140 | +6.762 | +6.836 | 7
PLAT | 6799.07 | 7359.39 | 21060 | +6.762 | +6.836 | 8
PLAT | 6336.84 | 5958.69 | 11140 | +6.300 | +6.374 | 8
PLAT | 6336.84 | 5958.69 | 11060 | +6.300 | +6.374 | 8
PLAT | 6336.84 | 5958.69 | 16140 | +6.300 | +6.374 | 8
PLAT | 6336.84 | 5958.69 | 16060 | +6.300 | +6.374 | 8
PLAT | 6336.84 | 5958.69 | 21140 | +6.300 | +6.374 | 7
PLAT | 6336.84 | 5958.69 | 21060 | +6.300 | +6.374 | 8
PLAT | 5874.61 | 4557.99 | 11140 | +5.837 | +5.912 | 8
PLAT | 5874.61 | 4557.99 | 11060 | +5.837 | +5.912 | 8
PLAT | 5874.61 | 4557.99 | 16140 | +5.837 | +5.912 | 8
PLAT | 5874.61 | 4557.99 | 16060 | +5.837 | +5.912 | 8
PLAT | 5874.61 | 4557.99 | 21140 | +5.837 | +5.912 | 7
PLAT | 5874.61 | 4557.99 | 21060 | +5.837 | +5.912 | 8
PLAT | 5412.38 | 3157.29 | 11140 | +5.375 | +5.450 | 8
PLAT | 5412.38 | 3157.29 | 11060 | +5.375 | +5.450 | 8
PLAT | 5412.38 | 3157.29 | 16140 | +5.375 | +5.450 | 8
PLAT | 5412.38 | 3157.29 | 16060 | +5.375 | +5.450 | 8
PLAT | 5412.38 | 3157.29 | 21140 | +5.375 | +5.450 | 7
PLAT | 5412.38 | 3157.29 | 21060 | +5.375 | +5.450 | 8
PLAT | 4950.15 | 1756.59 | 11140 | +4.913 | +4.987 | 8
PLAT | 4950.15 | 1756.59 | 11060 | +4.913 | +4.987 | 8
PLAT | 4950.15 | 1756.59 | 16140 | +4.913 | +4.987 | 8
PLAT | 4950.15 | 1756.59 | 16060 | +4.913 | +4.987 | 8
PLAT | 4950.15 | 1756.59 | 21140 | +4.913 | +4.987 | 7
PLAT | 4950.15 | 1756.59 | 21060 | +4.913 | +4.987 | 8
PLAT | 4487.92 | 355.886 | 21140 | +4.451 | +4.525 | 7
PLAT | 4487.92 | 355.886 | 21060 | +4.451 | +4.525 | 8
PLAT | 4487.92 | 355.886 | 16140 | +4.451 | +4.525 | 8
PLAT | 4487.92 | 355.886 | 16060 | +4.451 | +4.525 | 8
PLAT | 4487.92 | 355.886 | 11140 | +4.451 | +4.525 | 8
PLAT | 4487.92 | 355.886 | 11060 | +4.451 | +4.525 | 8
PLAT | 7261.3 | 8760.09 | 6140 | +7.224 | +7.299 | 8
PLAT | 7261.3 | 8760.09 | 6060 | +7.224 | +7.299 | 7
PLAT | 6799.07 | 7359.39 | 6140 | +6.762 | +6.836 | 8
PLAT | 6799.07 | 7359.39 | 6060 | +6.762 | +6.836 | 7
PLAT | 6336.84 | 5958.69 | 6140 | +6.300 | +6.374 | 8
PLAT | 6336.84 | 5958.69 | 6060 | +6.300 | +6.374 | 7
PLAT | 5874.61 | 4557.99 | 6140 | +5.837 | +5.912 | 8
PLAT | 5874.61 | 4557.99 | 6060 | +5.837 | +5.912 | 7
PLAT | 5412.38 | 3157.29 | 6140 | +5.375 | +5.450 | 8
PLAT | 5412.38 | 3157.29 | 6060 | +5.375 | +5.450 | 7
PLAT | 4950.15 | 1756.59 | 6140 | +4.913 | +4.987 | 8
PLAT | 4950.15 | 1756.59 | 6060 | +4.913 | +4.987 | 7
PLAT | 4487.92 | 17444.1 | 6060 | +4.451 | +4.525 | 7
PLAT | 4487.92 | 17444.1 | 6140 | +4.451 | +4.525 | 8
PLAT | 4487.92 | 355.886 | 6140 | +4.451 | +4.525 | 8
PLAT | 4487.92 | 355.886 | 6060 | +4.451 | +4.525 | 7

# IfcBeam: PL8*80 (24)
In: Undefined
Description: PL8*80; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5285.87 mm; Bottom elevation: +5.246; Top elevation: +5.326; Part mark: OX3; Assembly mark: 9; Phase: 2; Class: 7; Grade: S235JR; Profile: PL8*80; Name: OXYCOUPAGE; sets with these values: 2
Tekla Quantity - Net weight: 0.610636 kg; Gross weight: 0.803904 kg; Weight: 0.610636 kg; Net volume: 0.000077788 m3; Gross volume: 0.000077788 m3; Gross footprint area: 0.00096 m2; Area per tons: 39.5184 m2; Net surface area: 0.0241314 m2; Gross area: 0.012801 m2; Height: 80.0044 mm; Width: 8 mm; Length: 160.004 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 160.004 mm; OuterSurfaceArea: 0.0241314 m2; NetVolume: 0.000077788 m3; NetWeight: 0.610636 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm)
OXYCOUPAGE | 10311.5 | 25987
OXYCOUPAGE | 10311.5 | 26013
OXYCOUPAGE | 7488.48 | 11113
OXYCOUPAGE | 7488.48 | 11087
OXYCOUPAGE | 7488.48 | 16087
OXYCOUPAGE | 7488.48 | 16113
OXYCOUPAGE | 10311.5 | 6087
OXYCOUPAGE | 10311.5 | 11113
OXYCOUPAGE | 10311.5 | 6113
OXYCOUPAGE | 10311.5 | 16087
OXYCOUPAGE | 10311.5 | 16113
OXYCOUPAGE | 7488.48 | 6087
OXYCOUPAGE | 7488.48 | 6113
OXYCOUPAGE | 10311.5 | 11087
OXYCOUPAGE | 7488.48 | 21087
OXYCOUPAGE | 7488.48 | 21113
OXYCOUPAGE | 10311.5 | 21113
OXYCOUPAGE | 7488.48 | 25987
OXYCOUPAGE | 7488.48 | 26013
OXYCOUPAGE | 10311.5 | 21087
OXYCOUPAGE | 10311.5 | 1187
OXYCOUPAGE | 10311.5 | 1213
OXYCOUPAGE | 7488.48 | 1187
OXYCOUPAGE | 7488.48 | 1213

# IfcBeam: ROD40 (30)
In: Undefined
Description: ROD40; Material: STEEL/S235JR
Tekla Common - Phase: 2; Class: 4; Grade: S235JR; Profile: ROD40; Name: TIRAN; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 40 mm; Width: 40 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Area per tons (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
TIRAN | 4963.01 | 4447.93 | 16100 | +4.621 | +5.305 | TR2 | 2 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 4963.01 | 4447.93 | 11100 | +4.621 | +5.305 | TR2 | 1 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 5285.87 | 8900 | 6100 | +5.266 | +5.306 | TR3 | 9 | 27.3574 | 0.00348501 | 12.8918 | 0.352685 | 2791.19
TIRAN | 4963.01 | 13352.1 | 11100 | +4.621 | +5.305 | TR2 | 4 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 6219.13 | 9729.2 | 11100 | +5.315 | +7.122 | TR1 | 4 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 6219.13 | 8070.8 | 16100 | +5.315 | +7.122 | TR1 | 2 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 6219.13 | 9729.2 | 16100 | +5.315 | +7.122 | TR1 | 5 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 6219.13 | 9729.2 | 6100 | +5.315 | +7.122 | TR1 | 6 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 4963.01 | 13352.1 | 6100 | +4.621 | +5.305 | TR2 | 6 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 6219.13 | 8070.8 | 6100 | +5.315 | +7.122 | TR1 | 3 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 6219.13 | 8070.8 | 11100 | +5.315 | +7.122 | TR1 | 1 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 5285.87 | 8900 | 16100 | +5.266 | +5.306 | TR3 | 9 | 27.3574 | 0.00348501 | 12.8918 | 0.352685 | 2791.19
TIRAN | 4963.01 | 13352.1 | 16100 | +4.621 | +5.305 | TR2 | 5 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 5285.87 | 8900 | 11100 | +5.266 | +5.306 | TR3 | 9 | 27.3574 | 0.00348501 | 12.8918 | 0.352685 | 2791.19
TIRAN | 4963.01 | 4447.93 | 6100 | +4.621 | +5.305 | TR2 | 3 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 6219.13 | 8070.8 | 21100 | +5.315 | +7.122 | TR1 | 3 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 5285.87 | 8900 | 21100 | +5.266 | +5.306 | TR3 | 9 | 27.3574 | 0.00348501 | 12.8918 | 0.352685 | 2791.19
TIRAN | 6219.13 | 9729.2 | 21100 | +5.315 | +7.122 | TR1 | 6 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 4963.01 | 13352.1 | 21100 | +4.621 | +5.305 | TR2 | 6 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 4963.01 | 4447.93 | 21100 | +4.621 | +5.305 | TR2 | 3 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 4963.01 | 13352.1 | 26000 | +4.621 | +5.305 | TR2 | 6 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 6219.13 | 9729.2 | 26000 | +5.315 | +7.122 | TR1 | 6 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 5285.87 | 8900 | 26000 | +5.266 | +5.306 | TR3 | 9 | 27.3574 | 0.00348501 | 12.8918 | 0.352685 | 2791.19
TIRAN | 6219.13 | 8070.8 | 26000 | +5.315 | +7.122 | TR1 | 3 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 4963.01 | 4447.93 | 26000 | +4.621 | +5.305 | TR2 | 3 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 6219.13 | 9729.2 | 1200 | +5.315 | +7.122 | TR1 | 6 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 4963.01 | 13352.1 | 1200 | +4.621 | +5.305 | TR2 | 6 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 6219.13 | 8070.8 | 1200 | +5.315 | +7.122 | TR1 | 3 | 22.5631 | 0.00287428 | 12.9588 | 0.29239 | 2333.42
TIRAN | 4963.01 | 4447.93 | 1200 | +4.621 | +5.305 | TR2 | 3 | 58.0059 | 0.00738928 | 12.8435 | 0.745001 | 5918.16
TIRAN | 5285.87 | 8900 | 1200 | +5.266 | +5.306 | TR3 | 9 | 27.3574 | 0.00348501 | 12.8918 | 0.352685 | 2791.19

# IfcBeam: TUBE-139.7*4 (12)
In: Undefined
Description: TUBE-139.7*4; Material: STEEL/S235JR
Tekla Common - Top elevation: +4.659; Phase: 2; Class: 3; Grade: S235JR; Profile: TUBE-139.7*4; Name: POUTRE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 139.7 mm; Width: 139.7 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Part mark | Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POUTRE | 4438.51 | 16498 | 11100 | +4.247 | T3 | 4 | 5.03552 | 5.18928 | 0.000641467 | 0.000661054 | 33.5106 | 0.168743 | 0.172456 | 412.111
POUTRE | 4438.51 | 16498 | 16100 | +4.247 | T3 | 5 | 5.03552 | 5.18928 | 0.000641467 | 0.000661054 | 33.5106 | 0.168743 | 0.172456 | 412.111
POUTRE | 4438.51 | 16498 | 6100 | +4.247 | T3 | 6 | 5.03552 | 5.18928 | 0.000641467 | 0.000661054 | 33.5106 | 0.168743 | 0.172456 | 412.111
POUTRE | 4433.44 | 1301.95 | 6100 | +4.237 | T2 | 3 | 5.16883 | 5.32259 | 0.00065845 | 0.000678037 | 33.4946 | 0.173128 | 0.17684 | 422.111
POUTRE | 4433.44 | 1301.95 | 16100 | +4.237 | T2 | 2 | 5.16883 | 5.32259 | 0.00065845 | 0.000678037 | 33.4946 | 0.173128 | 0.17684 | 422.111
POUTRE | 4433.44 | 1301.95 | 11100 | +4.237 | T2 | 1 | 5.16883 | 5.32259 | 0.00065845 | 0.000678037 | 33.4946 | 0.173128 | 0.17684 | 422.111
POUTRE | 4438.51 | 16498 | 21100 | +4.247 | T3 | 6 | 5.03552 | 5.18928 | 0.000641467 | 0.000661054 | 33.5106 | 0.168743 | 0.172456 | 412.111
POUTRE | 4433.44 | 1301.95 | 21100 | +4.237 | T2 | 3 | 5.16883 | 5.32259 | 0.00065845 | 0.000678037 | 33.4946 | 0.173128 | 0.17684 | 422.111
POUTRE | 4438.51 | 16498 | 26000 | +4.247 | T3 | 6 | 5.03552 | 5.18928 | 0.000641467 | 0.000661054 | 33.5106 | 0.168743 | 0.172456 | 412.111
POUTRE | 4433.44 | 1301.95 | 26000 | +4.237 | T2 | 3 | 5.16883 | 5.32259 | 0.00065845 | 0.000678037 | 33.4946 | 0.173128 | 0.17684 | 422.111
POUTRE | 4433.44 | 1301.95 | 1200 | +4.237 | T2 | 3 | 5.16883 | 5.32259 | 0.00065845 | 0.000678037 | 33.4946 | 0.173128 | 0.17684 | 422.111
POUTRE | 4438.51 | 16498 | 1200 | +4.247 | T3 | 6 | 5.03552 | 5.18928 | 0.000641467 | 0.000661054 | 33.5106 | 0.168743 | 0.172456 | 412.111

# IfcBeam: TUBE-76.1*2.9 (12)
In: Undefined
Description: TUBE-76.1*2.9; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: 5759.08 mm; Bottom elevation: +5.294; Top elevation: +6.204; Part mark: P1; Phase: 2; Class: 3; Grade: S235JR; Profile: TUBE-76.1*2.9; Name: TUBE; sets with these values: 2
Tekla Quantity - Net weight: 7.7501 kg; Gross weight: 7.79504 kg; Weight: 7.7501 kg; Net volume: 0.000987273 m3; Gross volume: 0.000992998 m3; Gross footprint area: 0 m2; Area per tons: 46.0446 m2; Net surface area: 0.35685 m2; Gross area: 0.358474 m2; Height: 76.1 mm; Width: 76.1 mm; Length: 1526.7 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 1526.7 mm; OuterSurfaceArea: 0.35685 m2; NetVolume: 0.000987273 m3; NetWeight: 7.7501 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
TUBE | 11184.7 | 11100 | 4
TUBE | 6615.26 | 11100 | 1
TUBE | 11184.7 | 6100 | 6
TUBE | 6615.26 | 6100 | 3
TUBE | 11184.7 | 16100 | 5
TUBE | 6615.26 | 16100 | 2
TUBE | 6615.26 | 21100 | 3
TUBE | 11184.7 | 21100 | 6
TUBE | 11184.7 | 26000 | 6
TUBE | 6615.26 | 26000 | 3
TUBE | 11184.7 | 1200 | 6
TUBE | 6615.26 | 1200 | 3

# IfcBeam: TUBE-88.9*3.2 (10)
In: Undefined
Description: TUBE-88.9*3.2; Material: STEEL/S235JR
Tekla Common - Phase: 4; Class: 4; Grade: S235JR; Profile: TUBE-88.9*3.2; Name: CONTREVENTEMENT; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Height: 88.9 mm; Width: 88.9 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = Weight (kg) = NetWeight (kg) | Gross weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Area per tons (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
CONTREVENTEMENT | 6758.97 | 10341.9 | 12337.3 | +6.277 | +7.240 | P5 | CV2 | 24.1941 | 24.2745 | 0.00308205 | 0.00309229 | 41.5758 | 1.00589 | 1.00816 | 3612.38
CONTREVENTEMENT | 5487.8 | 14194 | 12345.6 | +4.706 | +6.269 | P6 | CV3 | 35.2896 | 35.37 | 0.0044955 | 0.00450574 | 41.5504 | 1.4663 | 1.46857 | 5263.56
CONTREVENTEMENT | 6758.97 | 10341.9 | 14862.7 | +6.277 | +7.240 | P5 | CV2 | 24.1941 | 24.2745 | 0.00308205 | 0.00309229 | 41.5758 | 1.00589 | 1.00816 | 3612.38
CONTREVENTEMENT | 5487.8 | 14194 | 14854.4 | +4.706 | +6.269 | P6 | CV3 | 35.2896 | 35.37 | 0.0044955 | 0.00450574 | 41.5504 | 1.4663 | 1.46857 | 5263.56
CONTREVENTEMENT | 6264.95 | 11807.1 | 13600 | +6.221 | +6.309 | P4 | CV1 | 32.0631 | 32.255 | 0.00408447 | 0.00410892 | 41.6041 | 1.33395 | 1.33932 | 4800
CONTREVENTEMENT | 6758.97 | 7458.05 | 14862.7 | +6.277 | +7.240 | P5 | CV2 | 24.1941 | 24.2745 | 0.00308205 | 0.00309229 | 41.5758 | 1.00589 | 1.00816 | 3612.38
CONTREVENTEMENT | 5487.8 | 3606 | 14854.4 | +4.706 | +6.269 | P6 | CV3 | 35.2896 | 35.37 | 0.0044955 | 0.00450574 | 41.5504 | 1.4663 | 1.46857 | 5263.56
CONTREVENTEMENT | 6758.97 | 7458.05 | 12337.3 | +6.277 | +7.240 | P5 | CV2 | 24.1941 | 24.2745 | 0.00308205 | 0.00309229 | 41.5758 | 1.00589 | 1.00816 | 3612.38
CONTREVENTEMENT | 5487.8 | 3606 | 12345.6 | +4.706 | +6.269 | P6 | CV3 | 35.2896 | 35.37 | 0.0044955 | 0.00450574 | 41.5504 | 1.4663 | 1.46857 | 5263.56
CONTREVENTEMENT | 6264.95 | 5992.93 | 13600 | +6.221 | +6.309 | P4 | CV1 | 32.0631 | 32.255 | 0.00408447 | 0.00410892 | 41.6041 | 1.33395 | 1.33932 | 4800

# IfcBeam: TUBE-C-120*120*4 (70)
In: Undefined
Description: TUBE-C-120*120*4; Material: STEEL/S235JR
Tekla Common - Phase: 3; Class: 5; Grade: S235JR; Profile: TUBE-C-120*120*4; Name: PANNE; sets with these values: 2
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 32.7973 m2; Height: 120 mm; Width: 120 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = NetWeight (kg) | Gross weight (kg) = Weight (kg) | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PANNE | 7321.13 | 9059.66 | 8600 | +7.245 | +7.397 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 7321.13 | 9059.66 | 13600 | +7.245 | +7.397 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 7321.13 | 9059.66 | 24152.5 | +7.245 | +7.397 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 7321.13 | 9059.66 | 18600 | +7.245 | +7.397 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6858.9 | 10460.4 | 8600 | +6.783 | +6.935 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6858.9 | 10460.4 | 13600 | +6.783 | +6.935 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6858.9 | 10460.4 | 24152.5 | +6.783 | +6.935 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 6858.9 | 10460.4 | 18600 | +6.783 | +6.935 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6396.67 | 11861.1 | 8600 | +6.321 | +6.472 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6396.67 | 11861.1 | 13600 | +6.321 | +6.472 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6396.67 | 11861.1 | 24152.5 | +6.321 | +6.472 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 6396.67 | 11861.1 | 18600 | +6.321 | +6.472 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5934.44 | 13261.8 | 8600 | +5.859 | +6.010 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5934.44 | 13261.8 | 13600 | +5.859 | +6.010 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5934.44 | 13261.8 | 24152.5 | +5.859 | +6.010 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5934.44 | 13261.8 | 18600 | +5.859 | +6.010 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5472.21 | 14662.5 | 8600 | +5.396 | +5.548 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5472.21 | 14662.5 | 13600 | +5.396 | +5.548 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5472.21 | 14662.5 | 24152.5 | +5.396 | +5.548 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5472.21 | 14662.5 | 18600 | +5.396 | +5.548 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5009.98 | 16063.2 | 8600 | +4.934 | +5.086 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5009.98 | 16063.2 | 13600 | +4.934 | +5.086 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5009.98 | 16063.2 | 24152.5 | +4.934 | +5.086 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5009.98 | 16063.2 | 18600 | +4.934 | +5.086 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 7321.13 | 8740.34 | 13600 | +7.245 | +7.397 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 7321.13 | 8740.34 | 24152.5 | +7.245 | +7.397 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 7321.13 | 8740.34 | 18600 | +7.245 | +7.397 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6858.9 | 7339.64 | 13600 | +6.783 | +6.935 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6858.9 | 7339.64 | 24152.5 | +6.783 | +6.935 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 6858.9 | 7339.64 | 18600 | +6.783 | +6.935 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6396.67 | 5938.94 | 13600 | +6.321 | +6.472 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6396.67 | 5938.94 | 24152.5 | +6.321 | +6.472 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 6396.67 | 5938.94 | 18600 | +6.321 | +6.472 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5934.44 | 4538.24 | 13600 | +5.859 | +6.010 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5934.44 | 4538.24 | 24152.5 | +5.859 | +6.010 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5934.44 | 4538.24 | 18600 | +5.859 | +6.010 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5472.21 | 3137.54 | 13600 | +5.396 | +5.548 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5472.21 | 3137.54 | 24152.5 | +5.396 | +5.548 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5472.21 | 3137.54 | 18600 | +5.396 | +5.548 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5009.98 | 1736.84 | 13600 | +4.934 | +5.086 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5009.98 | 1736.84 | 24152.5 | +4.934 | +5.086 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5009.98 | 1736.84 | 18600 | +4.934 | +5.086 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 7321.13 | 8740.34 | 8600 | +7.245 | +7.397 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6858.9 | 7339.64 | 8600 | +6.783 | +6.935 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 6396.67 | 5938.94 | 8600 | +6.321 | +6.472 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5934.44 | 4538.24 | 8600 | +5.859 | +6.010 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5472.21 | 3137.54 | 8600 | +5.396 | +5.548 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 5009.98 | 1736.84 | 8600 | +4.934 | +5.086 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 4547.75 | 17463.9 | 8600 | +4.472 | +4.624 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 4547.75 | 17463.9 | 13600 | +4.472 | +4.624 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 4547.75 | 17463.9 | 24152.5 | +4.472 | +4.624 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 4547.75 | 17463.9 | 18600 | +4.472 | +4.624 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 7321.13 | 9059.66 | 3047.5 | +7.245 | +7.397 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 6858.9 | 10460.4 | 3047.5 | +6.783 | +6.935 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 6396.67 | 11861.1 | 3047.5 | +6.321 | +6.472 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5934.44 | 13261.8 | 3047.5 | +5.859 | +6.010 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5472.21 | 14662.5 | 3047.5 | +5.396 | +5.548 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5009.98 | 16063.2 | 3047.5 | +4.934 | +5.086 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 4547.75 | 336.143 | 3047.5 | +4.472 | +4.624 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 4547.75 | 336.143 | 8600 | +4.472 | +4.624 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 4547.75 | 336.143 | 13600 | +4.472 | +4.624 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 4547.75 | 336.143 | 18600 | +4.472 | +4.624 | P3 | 8 | 72.7023 | 70.9004 | 0.00926144 | 0.0090319 | 2.39712 | 2.32534 | 4990
PANNE | 4547.75 | 336.143 | 24152.5 | +4.472 | +4.624 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5009.98 | 1736.84 | 3047.5 | +4.934 | +5.086 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5472.21 | 3137.54 | 3047.5 | +5.396 | +5.548 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 5934.44 | 4538.24 | 3047.5 | +5.859 | +6.010 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 6396.67 | 5938.94 | 3047.5 | +6.321 | +6.472 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 6858.9 | 7339.64 | 3047.5 | +6.783 | +6.935 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 7321.13 | 8740.34 | 3047.5 | +7.245 | +7.397 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095
PANNE | 4547.75 | 17463.9 | 3047.5 | +4.472 | +4.624 | P2 | 7 | 88.8017 | 86.6008 | 0.0113123 | 0.011032 | 2.92752 | 2.84027 | 6095

# IfcElementAssembly (116)
In: Undefined
Tekla Assembly - sets with these values: 2
Name | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit name | Assembly/Cast unit position code | Assembly/Cast unit Mark
TUBE-C-120*120*4 | 2.27964 | +5.375 | +5.548 | TUBE-C-120*120*4 | .-2/FAIT-A | 7
TUBE-C-120*120*4 | 2.27964 | +4.913 | +5.086 | TUBE-C-120*120*4 | .-2/FAIT-A | 7
TUBE-C-120*120*4 | 2.27964 | +4.451 | +4.624 | TUBE-C-120*120*4 | .-2/ | 7
ROD40 | 2.44254 | +5.246 | +5.326 | ROD40 | 1/B-A | 9
HEA160 | 33.2815 | +4.235 | +7.305 | HEA160 | 1/FAIT- | 6
TUBE-C-120*120*4 | 2.27964 | +5.837 | +6.010 | TUBE-C-120*120*4 | .-2/FAIT-A | 7
TUBE-C-120*120*4 | 2.27964 | +6.300 | +6.472 | TUBE-C-120*120*4 | .-2/FAIT-A | 7
TUBE-C-120*120*4 | 2.27964 | +4.451 | +4.624 | TUBE-C-120*120*4 | 5-/. | 7
TUBE-C-120*120*4 | 2.27964 | +4.451 | +4.624 | TUBE-C-120*120*4 | 5-/ | 7
TUBE-C-120*120*4 | 1.45068 | +4.451 | +4.624 | TUBE-C-120*120*4 | 4-5/. | 8
TUBE-C-120*120*4 | 1.45068 | +4.451 | +4.624 | TUBE-C-120*120*4 | 3-4/. | 8
TUBE-C-120*120*4 | 1.45068 | +4.451 | +4.624 | TUBE-C-120*120*4 | 2-3/. | 8
TUBE-C-120*120*4 | 2.27964 | +4.913 | +5.086 | TUBE-C-120*120*4 | .-2/B-FAIT | 7
TUBE-C-120*120*4 | 2.27964 | +5.375 | +5.548 | TUBE-C-120*120*4 | .-2/B-FAIT | 7
TUBE-C-120*120*4 | 2.27964 | +5.837 | +6.010 | TUBE-C-120*120*4 | .-2/B-FAIT | 7
TUBE-C-120*120*4 | 2.27964 | +6.300 | +6.472 | TUBE-C-120*120*4 | .-2/B-FAIT | 7
TUBE-C-120*120*4 | 2.27964 | +6.762 | +6.935 | TUBE-C-120*120*4 | .-2/B-FAIT | 7
2 x TUBE-C-120*120*4 | 2.27964 | +7.224 | +7.397 | TUBE-C-120*120*4 | .-2/FAIT | 7
TUBE-C-120*120*4 | 2.27964 | +4.451 | +4.624 | TUBE-C-120*120*4 | .-2/. | 7
HEA160 | 33.2815 | +4.225 | +7.305 | HEA160 | 1/.-FAIT | 3
4525*270 | 7623.72 | -0.300 | +4.225 | 4525*270 | 6->/A | AB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
4525*270 | 7623.72 | -0.300 | +4.225 | 4525*270 | 3-5/A | AB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
4525*270 | 7623.72 | -0.300 | +4.225 | 4525*270 | 2-4/A | AB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
4525*270 | 7623.72 | -0.300 | +4.225 | 4525*270 | <.-1/A | AB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
600*600 | 3909.6 | -0.300 | +4.225 | 600*600 | 5/A | PB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
600*600 | 3909.6 | -0.300 | +4.225 | 600*600 | 2/A | PB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
600*600 | 3909.6 | -0.300 | +4.225 | 600*600 | 6/B | PB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
600*600 | 3909.6 | -0.300 | +4.225 | 600*600 | 5/B | PB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
600*600 | 3909.6 | -0.300 | +4.225 | 600*600 | 4/B | PB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
600*600 | 3909.6 | -0.300 | +4.225 | 600*600 | 3/B | PB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
600*600 | 3909.6 | -0.300 | +4.225 | 600*600 | 2/B | PB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
600*600 | 3909.6 | -0.300 | +4.225 | 600*600 | 1/B | PB1 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assembly - Cast unit vertical position code: +0.0-+4225; Cast unit rebar weight: 0 kg
TUBE-C-120*120*4 | 1.45068 | +4.451 | +4.624 | TUBE-C-120*120*4 | 4-5/ | 8
TUBE-C-120*120*4 | 2.27964 | +6.762 | +6.935 | TUBE-C-120*120*4 | .-2/FAIT-A | 7
HEA160 | 33.2815 | +4.225 | +7.305 | HEA160 | 2/.-FAIT | 3
TUBE-C-120*120*4 | 1.45068 | +4.451 | +4.624 | TUBE-C-120*120*4 | 3-4/ | 8
TUBE-C-120*120*4 | 1.45068 | +4.451 | +4.624 | TUBE-C-120*120*4 | 2-3/ | 8
PL10*280 | 0 | +4.225 | +4.235 | PL10*280 | 1/A | 10
PL10*280 | 0 | +4.225 | +4.235 | PL10*280 | 2/A | 10
ROD40 | 2.44254 | +5.246 | +5.326 | ROD40 | 3/B-A | 9
HEA160 | 33.2815 | +4.235 | +7.305 | HEA160 | 2/FAIT- | 6
HEA160 | 34.4266 | +4.225 | +7.305 | HEA160 | 3/.-FAIT | 1
PL10*280 | 0 | +4.225 | +4.235 | PL10*280 | 3/A | 10
ROD40 | 2.44254 | +5.246 | +5.326 | ROD40 | 4/B-A | 9
HEA160 | 34.4266 | +4.235 | +7.305 | HEA160 | 3/FAIT- | 4
HEA160 | 34.4266 | +4.225 | +7.305 | HEA160 | 4/.-FAIT | 2
PL10*280 | 0 | +4.225 | +4.235 | PL10*280 | 4/A | 10
HEA160 | 34.4266 | +4.235 | +7.305 | HEA160 | 4/FAIT- | 5
HEA160 | 33.2815 | +4.225 | +7.305 | HEA160 | 5/.-FAIT | 3
PL10*280 | 0 | +4.225 | +4.235 | PL10*280 | 5/A | 10
HEA160 | 33.2815 | +4.235 | +7.305 | HEA160 | 5/FAIT- | 6
HEA160 | 33.2815 | +4.225 | +7.305 | HEA160 | 6/.-FAIT | 3
PL10*280 | 0 | +4.225 | +4.235 | PL10*280 | 6/A | 10
HEA160 | 33.2815 | +4.235 | +7.305 | HEA160 | 6/FAIT- | 6
TUBE-C-120*120*4 | 1.45068 | +4.913 | +5.086 | TUBE-C-120*120*4 | 2-3/B-FAIT | 8
TUBE-C-120*120*4 | 1.45068 | +5.375 | +5.548 | TUBE-C-120*120*4 | 2-3/B-FAIT | 8
TUBE-C-120*120*4 | 1.45068 | +5.837 | +6.010 | TUBE-C-120*120*4 | 2-3/B-FAIT | 8
TUBE-C-120*120*4 | 1.45068 | +6.300 | +6.472 | TUBE-C-120*120*4 | 2-3/B-FAIT | 8
TUBE-C-120*120*4 | 1.45068 | +6.762 | +6.935 | TUBE-C-120*120*4 | 2-3/B-FAIT | 8
2 x TUBE-C-120*120*4 | 1.45068 | +7.224 | +7.397 | TUBE-C-120*120*4 | 2-3/FAIT | 8
TUBE-C-120*120*4 | 1.45068 | +4.913 | +5.086 | TUBE-C-120*120*4 | 4-5/B-FAIT | 8
TUBE-C-120*120*4 | 2.27964 | +4.913 | +5.086 | TUBE-C-120*120*4 | 5-/B-FAIT | 7
TUBE-C-120*120*4 | 1.45068 | +4.913 | +5.086 | TUBE-C-120*120*4 | 3-4/B-FAIT | 8
TUBE-C-120*120*4 | 1.45068 | +5.375 | +5.548 | TUBE-C-120*120*4 | 4-5/B-FAIT | 8
TUBE-C-120*120*4 | 2.27964 | +5.375 | +5.548 | TUBE-C-120*120*4 | 5-/B-FAIT | 7
TUBE-C-120*120*4 | 1.45068 | +5.375 | +5.548 | TUBE-C-120*120*4 | 3-4/B-FAIT | 8
TUBE-C-120*120*4 | 1.45068 | +5.837 | +6.010 | TUBE-C-120*120*4 | 4-5/B-FAIT | 8
TUBE-C-120*120*4 | 2.27964 | +5.837 | +6.010 | TUBE-C-120*120*4 | 5-/B-FAIT | 7
TUBE-C-120*120*4 | 1.45068 | +5.837 | +6.010 | TUBE-C-120*120*4 | 3-4/B-FAIT | 8
TUBE-C-120*120*4 | 1.45068 | +6.300 | +6.472 | TUBE-C-120*120*4 | 4-5/B-FAIT | 8
TUBE-C-120*120*4 | 2.27964 | +6.300 | +6.472 | TUBE-C-120*120*4 | 5-/B-FAIT | 7
TUBE-C-120*120*4 | 1.45068 | +6.300 | +6.472 | TUBE-C-120*120*4 | 3-4/B-FAIT | 8
TUBE-C-120*120*4 | 1.45068 | +6.762 | +6.935 | TUBE-C-120*120*4 | 4-5/B-FAIT | 8
TUBE-C-120*120*4 | 2.27964 | +6.762 | +6.935 | TUBE-C-120*120*4 | 5-/B-FAIT | 7
TUBE-C-120*120*4 | 1.45068 | +6.762 | +6.935 | TUBE-C-120*120*4 | 3-4/B-FAIT | 8
2 x TUBE-C-120*120*4 | 1.45068 | +7.224 | +7.397 | TUBE-C-120*120*4 | 4-5/FAIT | 8
2 x TUBE-C-120*120*4 | 2.27964 | +7.224 | +7.397 | TUBE-C-120*120*4 | 5-/FAIT | 7
2 x TUBE-C-120*120*4 | 1.45068 | +7.224 | +7.397 | TUBE-C-120*120*4 | 3-4/FAIT | 8
TUBE-C-120*120*4 | 1.45068 | +4.913 | +5.086 | TUBE-C-120*120*4 | 4-5/FAIT-A | 8
TUBE-C-120*120*4 | 2.27964 | +4.913 | +5.086 | TUBE-C-120*120*4 | 5-/FAIT-A | 7
TUBE-C-120*120*4 | 1.45068 | +4.913 | +5.086 | TUBE-C-120*120*4 | 3-4/FAIT-A | 8
TUBE-C-120*120*4 | 1.45068 | +4.913 | +5.086 | TUBE-C-120*120*4 | 2-3/FAIT-A | 8
TUBE-C-120*120*4 | 1.45068 | +5.375 | +5.548 | TUBE-C-120*120*4 | 4-5/FAIT-A | 8
TUBE-C-120*120*4 | 2.27964 | +5.375 | +5.548 | TUBE-C-120*120*4 | 5-/FAIT-A | 7
TUBE-C-120*120*4 | 1.45068 | +5.375 | +5.548 | TUBE-C-120*120*4 | 3-4/FAIT-A | 8
TUBE-C-120*120*4 | 1.45068 | +5.375 | +5.548 | TUBE-C-120*120*4 | 2-3/FAIT-A | 8
TUBE-C-120*120*4 | 1.45068 | +5.837 | +6.010 | TUBE-C-120*120*4 | 4-5/FAIT-A | 8
TUBE-C-120*120*4 | 2.27964 | +5.837 | +6.010 | TUBE-C-120*120*4 | 5-/FAIT-A | 7
TUBE-C-120*120*4 | 1.45068 | +5.837 | +6.010 | TUBE-C-120*120*4 | 3-4/FAIT-A | 8
TUBE-C-120*120*4 | 1.45068 | +5.837 | +6.010 | TUBE-C-120*120*4 | 2-3/FAIT-A | 8
TUBE-C-120*120*4 | 1.45068 | +6.300 | +6.472 | TUBE-C-120*120*4 | 4-5/FAIT-A | 8
TUBE-C-120*120*4 | 2.27964 | +6.300 | +6.472 | TUBE-C-120*120*4 | 5-/FAIT-A | 7
TUBE-C-120*120*4 | 1.45068 | +6.300 | +6.472 | TUBE-C-120*120*4 | 3-4/FAIT-A | 8
TUBE-C-120*120*4 | 1.45068 | +6.300 | +6.472 | TUBE-C-120*120*4 | 2-3/FAIT-A | 8
TUBE-C-120*120*4 | 1.45068 | +6.762 | +6.935 | TUBE-C-120*120*4 | 4-5/FAIT-A | 8
TUBE-C-120*120*4 | 2.27964 | +6.762 | +6.935 | TUBE-C-120*120*4 | 5-/FAIT-A | 7
TUBE-C-120*120*4 | 1.45068 | +6.762 | +6.935 | TUBE-C-120*120*4 | 3-4/FAIT-A | 8
TUBE-C-120*120*4 | 1.45068 | +6.762 | +6.935 | TUBE-C-120*120*4 | 2-3/FAIT-A | 8
TUBE-88.9*3.2 | 7.23368 | +6.216 | +6.315 | TUBE-88.9*3.2 | 3-4/B-FAIT | CV1
2 x TUBE-88.9*3.2 | 2.4492 | +4.706 | +6.269 | TUBE-88.9*3.2 | 3-4/FAIT-A | CV3
TUBE-88.9*3.2 | 7.23368 | +6.216 | +6.315 | TUBE-88.9*3.2 | 3-4/FAIT-A | CV1
2 x TUBE-88.9*3.2 | 2.4492 | +4.706 | +6.269 | TUBE-88.9*3.2 | 3-4/B-FAIT | CV3
2 x TUBE-88.9*3.2 | 2.4492 | +6.277 | +7.240 | TUBE-88.9*3.2 | 3-4/B-FAIT | CV2
2 x TUBE-88.9*3.2 | 2.4492 | +6.277 | +7.240 | TUBE-88.9*3.2 | 3-4/FAIT-A | CV2
ROD40 | 2.44254 | +5.246 | +5.326 | ROD40 | 5/B-A | 9
ROD40 | 2.44254 | +5.246 | +5.326 | ROD40 | 6/B-A | 9
ROD40 | 2.44254 | +5.246 | +5.326 | ROD40 | 2/B-A | 9

# IfcMechanicalFastener: Bolt assembly (214)
In: Undefined
Tekla Fastener - Slotted hole y: 0 mm; Location: Montage; sets with these values: 2
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Washer count | Washer type | Washer name | Nut count | Nut type | Nut name | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt standard | Bolt Name
12 x Bolt assembly | 20 | 60 | 0 | PLA-8.8 | RONDELLE-M20-PLA-8.8 | 1 | E-8.8 | ECROU-M20-E-8.8 | 0 | 21 | 1 | 8.8 | M20*60
20 x Bolt assembly | 16 | 50 | 0 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 1 | E-6.8 | ECROU-M16-E-6.8 | 0 | 18 | 1 | 6.8 | M16*50
112 x Bolt assembly | 12 | 30 | 0 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 2 | E-6.8 | ECROU-M12-E-6.8 | 0 | 14 | 2 | 6.8 | M12*30
28 x Bolt assembly | 12 | 30 | 0 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 4 | E-6.8 | ECROU-M12-E-6.8 | 0 | 14 | 4 | 6.8 | M12*30
6 x Bolt assembly | 16 | 50 | 0 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 4 | E-6.8 | ECROU-M16-E-6.8 | 0 | 18 | 4 | 6.8 | M16*50
6 x Bolt assembly | 16 | 100 | 2 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 2 | E-6.8 | ECROU-M16-E-6.8 | 0 | 20 | 2 | HILTI-HSA | HILTI_HSA_M16X120
24 x Bolt assembly | 16 | 9 | 0 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 0 | E-6.8 | ECROU-M16-E-6.8 | 0 | 18 | 1 | 6.8 | M16*30
6 x Bolt assembly | 16 | 100 | 2 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 2 | E-6.8 | ECROU-M16-E-6.8 | 52 | 19 | 2 | HILTI-HSA | HILTI_HSA_M16X120

# IfcPlate: PL10*100 (20)
In: Undefined
Description: PL10*100; Material: STEEL/S235JR
Tekla Common - Phase: 4; Class: 4; Grade: S235JR; Profile: PL10*100; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Gross weight: 1.256 kg; Gross footprint area: 0 m2; Gross area: 0.016 m2; Height: 100 mm; Width: 10 mm; Length: 160 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net weight (kg) = Weight (kg) | Net volume (m3) = Gross volume (m3) | Area per tons (m2) | Net surface area (m2)
GOUSSET | 7196.92 | 9014.84 | 11196.1 | +7.163 | +7.227 | A2 | CV2 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 6321.03 | 11669.1 | 13478.6 | +6.290 | +6.355 | A2 | CV2 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 4749.4 | 16431.6 | 11177.5 | +4.717 | +4.783 | A2 | CV3 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 6226.19 | 11956.4 | 13513.7 | +6.193 | +6.258 | A2 | CV3 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 7196.92 | 9014.84 | 16003.9 | +7.163 | +7.227 | A2 | CV2 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 6321.03 | 11669.1 | 13721.4 | +6.290 | +6.355 | A2 | CV2 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 4749.4 | 16431.6 | 16022.5 | +4.717 | +4.783 | A2 | CV3 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 6226.19 | 11956.4 | 13686.3 | +6.193 | +6.258 | A2 | CV3 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 6264.96 | 11807.1 | 15994.8 | +6.216 | +6.314 | A1 | CV1 | 1.16672 | 0.000148627 | 29.5612 | 0.0344898
GOUSSET | 6264.96 | 11807.1 | 11205.2 | +6.216 | +6.314 | A1 | CV1 | 1.16672 | 0.000148627 | 29.5612 | 0.0344898
GOUSSET | 7196.92 | 8785.15 | 16003.9 | +7.163 | +7.227 | A2 | CV2 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 6321.03 | 6130.94 | 13721.4 | +6.290 | +6.355 | A2 | CV2 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
GOUSSET | 4749.4 | 1368.43 | 16022.5 | +4.717 | +4.783 | A2 | CV3 | 1.2246 | 0.000156 | 29.5327 | 0.0361657
